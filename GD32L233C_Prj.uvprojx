# Keil uVision project GD32L233C_Prj.uvprojx, settings and files
target Gd32L233C_START (6240000::V6.24::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32L233C_Prj
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-invalid-source-encoding
  c include: .\gd32_sys;.\app;.\bsp;.\middle;.\Firmware\CMSIS\GD\GD32L23x\Include;.\Firmware\GD32L23x_standard_peripheral\Include;.\FreeRTOS\include;.\FreeRTOS\config;.\FreeRTOS\portable\GCC\ARM_CM23_NTZ\non_secure
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./app/: main.c app_motor.c app_motor.h app_console.c app_console.h
  group bsp
    ./bsp/: bsp_config.h bsp_motor.c bsp_motor.h bsp_din.c bsp_din.h bsp_uart.c bsp_uart.h
  group Firmware
    ./Firmware/GD32L23x_standard_peripheral/Source/: gd32l23x_adc.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_ctc.c gd32l23x_dac.c gd32l23x_dbg.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_fwdgt.c gd32l23x_gpio.c gd32l23x_i2c.c gd32l23x_lptimer.c gd32l23x_lpuart.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_rtc.c gd32l23x_slcd.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_usart.c gd32l23x_vref.c gd32l23x_wwdgt.c
    ./Firmware/GD32L23x_standard_peripheral/Include/: gd32l23x_adc.h gd32l23x_cau.h gd32l23x_cmp.h gd32l23x_crc.h gd32l23x_ctc.h gd32l23x_dac.h gd32l23x_dbg.h gd32l23x_dma.h gd32l23x_exti.h gd32l23x_fmc.h gd32l23x_fwdgt.h gd32l23x_gpio.h gd32l23x_i2c.h gd32l23x_lptimer.h gd32l23x_lpuart.h gd32l23x_misc.h gd32l23x_pmu.h gd32l23x_rcu.h gd32l23x_rtc.h gd32l23x_slcd.h gd32l23x_spi.h gd32l23x_syscfg.h gd32l23x_timer.h gd32l23x_trng.h gd32l23x_usart.h gd32l23x_vref.h gd32l23x_wwdgt.h
  group gd32_sys
    ./gd32_sys/: gd32l23x_it.c gd32l23x_it.h gd32l23x_libopt.h systick.c systick.h
  group CMSIS
    ./Firmware/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l23x.s
    ./Firmware/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
    ./Firmware/CMSIS/GD/GD32L23x/Include/: system_gd32l23x.h gd32l23x.h
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ./FreeRTOS/config/: FreeRTOSConfig.h
    ./FreeRTOS/portable/GCC/ARM_CM23_NTZ/non_secure/: port.c portasm.c portasm.h portmacro.h
software components: CMSIS:CORE 5.0.2
